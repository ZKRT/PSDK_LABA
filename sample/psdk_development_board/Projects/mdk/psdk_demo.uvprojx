# Keil uVision project psdk_demo.uvprojx, settings and files
target Psdk_Demo_Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: psdk_demo +hex
  AfterMake: d:\Keil_v5\ARM\ARMCC\Bin\fromelf.exe .\Objects\psdk_demo.axf --bin --output .\psdk_demo.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX
  c misc: -DHSE_VALUE=8000000
  c include: ..\..\Application;..\..\Application\psdk_test;..\..\Drivers\BSP;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\psdk_arch\arch_rtos\arch_rtos_cmsis;..\..\..\..\psdk_config;..\..\..\..\psdk_core\inc;..\..\..\..\psdk_upper\inc;..\..\Middlewares\FreeRTOS\Source\CMSIS_RTOS;..\..\Middlewares\FreeRTOS\Source\include;..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application/user
    ../../Application/: app_infor.h application.c freertos.c main.c
  group application/user/app/psdk_test
    ../../Application/psdk_test/: test_app_func.c test_msg_push.c test_payload_cam_emu.c test_payload_gimbal_emu.c
  group mid/psdk/core
    ../../../../psdk_core/src/: psdk_debug.c psdk_md5.c psdk_aes.c psdk_crc.c psdk_proto.c psdk_proto_parse.c
  group mid/psdk/arch
    ../../../../psdk_arch/arch_rtos/arch_rtos_cmsis/: psdk_arch_sys.c
  group mid/psdk/upper
    ../../../../psdk_upper/src/: psdk_app_func.c psdk_msg_subcribe.c psdk_upper.c psdk_payload_camera.c psdk_payload_gimbal.c
  group mid/freertos/port
    ../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group mid/freertos/src
    ../../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group mid/freertos/cmsis
    ../../Middlewares/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group drv/bsp
    ../../Drivers/BSP/: stm32f4xx_it.c dji_ringbuffer.c log_printf.c sys.c led_button_switch.c ms5607.c uart.c flash.c
  group drv/cmsis
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group drv/stm32f4_std_driver
    ../../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
